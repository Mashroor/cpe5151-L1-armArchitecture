# Keil uVision project Lab1Proj.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: AT91SAM7SE512 Atmel
  cpu: IRAM(0x200000-0x207FFF) IROM(0x100000-0x17FFFF) CLOCK(18432000) CPUTYPE(ARM7TDMI)
  output: Lab1Proj
  c flags: Optim=1
  memory RVCT4: ROM 0x100000 size 0x80000
  memory RVCT9: RAM 0x200000 size 0x8000
  group Source Group 1
    ./: SAM7.s Experiment1.c Assembly_Exp1.s
